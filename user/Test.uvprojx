# Keil uVision project Test.uvprojx, settings and files
target freertos (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lsc
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\freertos\include;..\lib
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./: main.c gpio_out.c pin_config.h gpio_out.h gpio_in.c gpio_in.h rs232.c rs232.h rs485.c rs485.h usart_debug.c usart_debug.h delay_us.c delay_us.h dht11.c dht11.h ds18b20.c ds18b20.h infrared.c infrared.h sensor_adc.c sensor_adc.h encoder.c encoder.h timer_pwm.c timer_pwm.h ch451.c ch451.h lcd12864.c lcd12864.h relay.c relay.h stepper.c stepper.h tlc5615.c tlc5615.h freertos_tasks.c freertos_tasks.h
  group lib
    ../lib/: sys.c delay.c key.c led.c usart.c timer.c tsensor.c lsens.c adc.c
  group freertos
    ../freertos/: croutine.c heap_2.c list.c port.c queue.c tasks.c timers.c
software components: CMSIS:CORE 5.2.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
